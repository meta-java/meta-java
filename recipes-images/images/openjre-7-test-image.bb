IMAGE_INSTALL:append = " openjdk-7-jre "

inherit openjre-test-image
