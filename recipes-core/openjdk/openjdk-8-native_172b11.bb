require openjdk-8-release-${PV}.inc
require openjdk-8-native.inc
