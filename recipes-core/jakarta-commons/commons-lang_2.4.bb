require jakarta-commons.inc
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=3b83ef96387f14655fc854ddc3c6bd57"

PR = "${INC_PR}.1"

DESCRIPTION = "Set of Java classes that provide helper methods for the standard java.lang classes"

SRC_URI = "http://archive.apache.org/dist/commons/lang/source/${BP}-src.tar.gz"


SRC_URI[sha256sum] = "2445238cd0eb167e99a1147394f61325490559f3df7e7e8f628043fb70cbf2f4"
