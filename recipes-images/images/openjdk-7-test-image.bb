IMAGE_INSTALL:append = " openjdk-7-jdk "

inherit openjdk-test-image
