require openjdk-8-release.inc
require openjdk-8-native.inc
