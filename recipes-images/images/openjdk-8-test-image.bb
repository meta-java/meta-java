IMAGE_INSTALL:append = " openjdk-8 "

inherit openjdk-test-image
