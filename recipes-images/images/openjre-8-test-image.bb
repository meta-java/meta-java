IMAGE_INSTALL:append = " openjre-8 "

inherit openjre-test-image
