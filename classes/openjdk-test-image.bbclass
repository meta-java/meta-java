DESCRIPTION = "An image for OpenJDK testing purposes"

TEST_SUITES:append = " javac"

inherit openjre-test-image
